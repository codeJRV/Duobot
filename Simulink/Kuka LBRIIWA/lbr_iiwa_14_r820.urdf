Commit message: NewKuka Added

File: Simulink/Kuka LBRIIWA/lbr_iiwa_14_r820.urdf (robot description, URDF)
Before this commit: robot kuka_lbr_iiwa_14_r820, 10 links, 9 joints
Links:
- link base_link: mass None -> 10
